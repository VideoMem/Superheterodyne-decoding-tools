options:
  parameters:
    author: VideoMem
    copyright: GPL
    generate_options: qt_gui
    id: Drift_plotter
    output_language: python
    title: Carrier Jitter
  states: {}

blocks:
- name: FFT_bin_size
  id: variable
  parameters:
    value: if_rate/FFT_points
  states: {}
- name: FFT_carrier_bin
  id: variable
  parameters:
    value: round(L_carrier/FFT_bin_size)
  states: {}
- name: FFT_points
  id: variable
  parameters:
    value: pow(2,FFT_points_order)
  states: {}
- name: FFT_points_order
  id: variable
  parameters:
    value: '10'
  states: {}
- name: FM_HPF
  id: variable
  parameters:
    value: '120'
  states: {}
- name: Fh
  id: variable
  parameters:
    value: Fv*lines_per_frame/2
  states: {}
- name: Fv
  id: variable
  parameters:
    comment: |-
      50 (PAL)
      60 (NTSC)
    value: '60'
  states: {}
- name: L_carrier
  id: variable
  parameters:
    value: L_carrier_ref + carrierL_fine + center_freq
  states: {}
- name: L_carrier_ref
  id: variable
  parameters:
    value: 146.25* Fh
  states: {}
- name: R_carrier_ref
  id: variable
  parameters:
    value: 178.75 * Fh
  states: {}
- name: VCO_deviation
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 8e3
  states: {}
- name: carrierL_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:1,0,1,1
    label: L Fine Tune
    orient: Qt.Horizontal
    start: '-5e3'
    step: '1'
    stop: 5e3
    value: '0'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: Center Fine
    min_len: '300'
    orient: Qt.Horizontal
    start: '-10e3'
    step: '0.1'
    stop: 10e3
    value: '0'
  states: {}
- name: half_VCO_deviation
  id: variable
  parameters:
    value: VCO_deviation/2
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: nearest.power(samp_rate/4,2)
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      625 (PAL)
      525 (NTSC)
      624 (PAL 624)
    value: '525'
  states: {}
- name: op_VCO_deviation
  id: variable
  parameters:
    value: VCO_deviation/3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: sharpness
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: Transition
    min_len: '300'
    orient: Qt.Horizontal
    rangeType: int
    start: int(op_VCO_deviation/4)
    step: '1'
    stop: int(op_VCO_deviation*2)
    value: round(op_VCO_deviation/2)
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,1,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.7'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: L_carrier
    offset: '0'
    phase: '0'
    samp_rate: if_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: L_carrier
    offset: '0'
    phase: '0'
    samp_rate: if_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: L_carrier + VCO_deviation / 2
    low_cutoff_freq: 'L_carrier - VCO_deviation / 2 '
    samp_rate: if_rate
    type: fir_filter_ccf
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: round(if_rate /  FM_HPF)
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sebastian/sdr/test_sample.r16
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: FFT_points
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: FFT_points
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: round(if_rate /  FM_HPF)
    max_iter: '4000'
    scale: 1/round(if_rate / FM_HPF)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1e-3'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '0x20'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: FFT_carrier_bin+1
    type: complex
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: FFT_carrier_bin+1
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: FFT_points
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: FFT_points
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.5'
    samp_rate: audio_rate
    sensitivity: 2*math.pi*440
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: FFT_points
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: FFT_points
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: phase_shift.wav
    samp_rate: round(if_rate/FFT_points)
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: phase_note.wav
    samp_rate: round(audio_rate)
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: round(if_rate/FFT_points)
    long_form: 'True'
    type: ff
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: FFT_points
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(FFT_points)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: FFT_points
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(FFT_points)
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '14'
    cutoff_freq: 2e6
    decim: '1'
    gain: '1'
    samp_rate: if_rate
    type: fir_filter_fff
    width: 500e3
    win: firdes.WIN_KAISER
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '60'
    decim: '1'
    gain: '1'
    samp_rate: if_rate/FFT_points
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_KAISER
  states: {}
- name: nearest
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\nfrom math import log\n\ndef power(value, base):\n\tn = round(log(value,base))\n\treturn pow(base,n)\t\n\n\t\n"
  states: {}
- name: pipe_source_1
  id: pipe_source
  parameters:
    command: ld-ldf-reader /home/sebastian/Downloads/VTR/LD/AC3.ldf
    out_type: short
    out_vlen: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: if_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@0
    legend: 'False'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_KAISER
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: if_rate
    fc: '0'
    fftsize: FFT_points
    freqhalf: 'False'
    legend: 'False'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: tabs@0
    legend: 'False'
    name: '"Phase Shift"'
    size: '65535'
    srate: if_rate/FFT_points
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    legend: 'False'
    nconnections: '2'
    size: '1024'
    srate: if_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(if_rate/samp_rate).limit_denominator(1000).denominator
    interp: Fraction(if_rate/samp_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: Fraction((if_rate/FFT_points)/audio_rate).limit_denominator(1000).numerator
    interp: Fraction((if_rate/FFT_points)/audio_rate).limit_denominator(1000).denominator
    taps: ''
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Main
    label1: Noise gate
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AGC_if
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rf
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: CH1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AGC_if
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: CH1
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_stream_to_vector_0, '0']
- [band_pass_filter_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [band_pass_filter_0_0, '0', virtual_sink_2, '0']
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_real_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_delay_1, '0', blocks_sub_xx_0_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_null_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_skiphead_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_sub_xx_0, '0', low_pass_filter_0, '0']
- [blocks_sub_xx_0_0, '0', high_pass_filter_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vco_f_0, '0', blocks_wavfile_sink_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_skiphead_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_skiphead_0_0, '0']
- [dc_blocker_xx_1, '0', rational_resampler_xxx_1, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [high_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [high_pass_filter_0, '0', virtual_sink_0_0, '0']
- [low_pass_filter_0, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_1, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [pipe_source_1, '0', blocks_short_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_1, '0']
- [rational_resampler_xxx_0, '0', blocks_moving_average_xx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_0, '0']
- [virtual_source_0, '0', blocks_null_sink_0, '0']
- [virtual_source_4, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
