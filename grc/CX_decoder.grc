options:
  parameters:
    author: VideoMem
    copyright: GPL
    description: Audio CX Noise Reduction
    generate_options: qt_gui
    id: CX_NR
    output_language: python
    title: CX decoder
  states: {}

blocks:
- name: bass_boost
  id: variable_qtgui_check_box
  parameters:
    'false': '0.0'
    gui_hint: tabs@1
    label: Bass Boost
    'true': '1.0'
    type: real
    value: '1'
  states: {}
- name: ctrl_delay
  id: variable_qtgui_range
  parameters:
    comment: |-
      9000 (fast attack)
      7721 (something smooth attack)
    gui_hint: tabs@1
    label: Control Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 40e3
    value: '9000'
  states: {}
- name: ctrl_envelope
  id: variable_function_probe
  parameters:
    block_id: envelope_probe
    function_name: level
    poll_rate: ctrl_rate
    value: '1'
  states: {}
- name: ctrl_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Control Gain
    orient: Qt.Horizontal
    start: 1/12
    step: '0.001'
    stop: '2'
    value: '1'
  states: {}
- name: ctrl_rate
  id: variable
  parameters:
    value: round(samp_rate/decimation)
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: diode_drop
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: dry
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Dry
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.33'
  states: {}
- name: knee_point
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Knee point
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.0600'
  states: {}
- name: min_average
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: test_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0
    label: Preamp Gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {}
- name: test_tone_enable
  id: variable_qtgui_check_box
  parameters:
    'false': '0.0'
    gui_hint: tabs@1
    label: Test Tone
    'true': '1.0'
    type: real
    value: '0.0'
  states: {}
- name: tp1_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: TP1 gain
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.52'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: knee_point
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_2
  id: analog_const_source_x
  parameters:
    const: test_tone_enable
    type: float
  states: {}
- name: analog_const_source_x_2_0
  id: analog_const_source_x
  parameters:
    const: bass_boost
    type: float
  states: {}
- name: analog_const_source_x_2_0_0
  id: analog_const_source_x
  parameters:
    const: bass_boost
    type: float
  states: {}
- name: analog_const_source_x_2_1
  id: analog_const_source_x
  parameters:
    const: 1-test_tone_enable
    type: float
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    comment: '250e-6'
    samp_rate: ctrl_rate
    tau: '250e-6'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    comment: '2e-3'
    samp_rate: ctrl_rate
    tau: '2.5e-3'
  states: {}
- name: analog_fm_deemph_0_1
  id: analog_fm_deemph
  parameters:
    samp_rate: ctrl_rate
    tau: '30e-3'
  states: {}
- name: analog_fm_deemph_0_1_0
  id: analog_fm_deemph
  parameters:
    samp_rate: ctrl_rate
    tau: '200e-3'
  states: {}
- name: analog_fm_preemph_1
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: ctrl_rate
    tau: '30e-3'
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: '15'
    lo: '0'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: '15'
    lo: '0'
  states: {}
- name: analog_rail_ff_0_0_0
  id: analog_rail_ff
  parameters:
    hi: '15'
    lo: '0'
  states: {}
- name: analog_rail_ff_1
  id: analog_rail_ff
  parameters:
    hi: 2 - dry
    lo: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 1/2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: test_gain/6
    freq: '876'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: round(samp_rate)
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: default
    num_outputs: '2'
    samp_rate: round(samp_rate)
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_1_1
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_1_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_4
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_4_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_5
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_5_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_6
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_7
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_8
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_9
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_9_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: ctrl_delay
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: ctrl_delay
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: ctrl_delay
    type: float
  states: {}
- name: blocks_float_to_uchar_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_0_0_0_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: ctrl_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_10
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 -(bass_boost/2)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_10_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 -(bass_boost/2)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0_1_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: test_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: test_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: tp1_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.04'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_6
  id: blocks_multiply_const_vxx
  parameters:
    const: dry
    type: float
  states: {}
- name: blocks_multiply_const_vxx_6_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ctrl_envelope
    type: float
  states: {}
- name: blocks_multiply_const_vxx_7
  id: blocks_multiply_const_vxx
  parameters:
    const: dry
    type: float
  states: {}
- name: blocks_multiply_const_vxx_7_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ctrl_envelope
    type: float
  states: {}
- name: blocks_multiply_const_vxx_8
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_8_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_9
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_9_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_9_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_9_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Diode drop emulator
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_1_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_1_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_1_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_4
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_4_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_4_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_4_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_4_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_4_2_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_5_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_6
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_7
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_0_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_sample_and_hold_xx_0_0_0_0
  id: blocks_sample_and_hold_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: diode_drop
    init: '0'
    low: diode_drop
  states: {}
- name: blocks_threshold_ff_1_0
  id: blocks_threshold_ff
  parameters:
    high: diode_drop
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_1_0_1
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '-diode_drop'
  states: {}
- name: blocks_threshold_ff_1_0_2
  id: blocks_threshold_ff
  parameters:
    high: diode_drop
    init: '0'
    low: diode_drop
  states: {}
- name: blocks_threshold_ff_1_1
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_threshold_ff_1_1_0
  id: blocks_threshold_ff
  parameters:
    high: '0'
    init: '0'
    low: '0'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: CX_decoded_output_r.wav
    nchan: '2'
    samp_rate: round(samp_rate)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/sebastian/Downloads/VTR/HIFI/vr/vrinternational.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: envelope_probe
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '500'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '250'
    win: firdes.WIN_KAISER
  states: {}
- name: high_pass_filter_0_1
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '500'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '250'
    win: firdes.WIN_KAISER
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '300'
    decim: '1'
    gain: '9.3'
    samp_rate: ctrl_rate
    type: fir_filter_fff
    width: '150'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '10'
    decim: '1'
    gain: '1'
    samp_rate: ctrl_rate
    type: fir_filter_fff
    width: '10'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '120'
    decim: '1'
    gain: '0.5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '800'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_3
  id: low_pass_filter
  parameters:
    cutoff_freq: '120'
    decim: '1'
    gain: '0.5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '800'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    color1: ("white", "black")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0
    label1: Gain
    max: '2'
    min: '0'
    name: ''
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: L
    label2: R
    max: '5'
    min: '0'
    name: Output
    nconnections: '2'
    type: float
    unit1: Vpp x10
    unit2: Vpp x10
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alpha2: '0.3'
    legend: 'False'
    name: '"Envelope"'
    nconnections: '2'
    size: ctrl_rate*5
    srate: ctrl_rate
    tr_chan: '1'
    tr_delay: '0.1'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '2.2'
    ymin: '-0.1'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: ''
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Main
    label1: Advanced
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rect_L
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fast_attack_release
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: enable
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: attack
  states: {}
- name: virtual_sink_2_0_0
  id: virtual_sink
  parameters:
    stream_id: not_attack
  states: {}
- name: virtual_sink_2_0_0_0
  id: virtual_sink
  parameters:
    stream_id: transition
  states: {}
- name: virtual_sink_2_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: attack_hold
  states: {}
- name: virtual_sink_2_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: decay_hold
  states: {}
- name: virtual_sink_2_0_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: attack_decay
  states: {}
- name: virtual_sink_2_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: not_transition
  states: {}
- name: virtual_sink_2_0_0_0_1_0
  id: virtual_sink
  parameters:
    stream_id: not_attack_decay
  states: {}
- name: virtual_sink_2_0_0_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: small_signal
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: test_tone
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: envelope
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: env
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: pre
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: TPy
  states: {}
- name: virtual_sink_7_0
  id: virtual_sink
  parameters:
    stream_id: TPz
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rect_L
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fast_attack_release
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: fast_attack_release
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: test_tone
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: not_attack
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: envelope
  states: {}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: pre
  states: {}
- name: virtual_source_6_0_0
  id: virtual_source
  parameters:
    stream_id: attack
  states: {}
- name: virtual_source_6_0_0_0
  id: virtual_source
  parameters:
    stream_id: not_attack
  states: {}
- name: virtual_source_6_0_0_1
  id: virtual_source
  parameters:
    stream_id: transition
  states: {}
- name: virtual_source_6_0_1
  id: virtual_source
  parameters:
    stream_id: attack
  states: {}
- name: virtual_source_6_0_1_0
  id: virtual_source
  parameters:
    stream_id: not_attack
  states: {}
- name: virtual_source_6_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: not_transition
  states: {}
- name: virtual_source_6_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: transition
  states: {}
- name: virtual_source_6_0_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: attack_hold
  states: {}
- name: virtual_source_6_0_1_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: attack_decay
  states: {}
- name: virtual_source_6_0_1_0_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: not_attack_decay
  states: {}
- name: virtual_source_6_0_1_0_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: transition
  states: {}
- name: virtual_source_6_0_1_0_0_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: transition
  states: {}
- name: virtual_source_6_0_1_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: decay_hold
  states: {}
- name: virtual_source_6_0_1_0_0_1_2
  id: virtual_source
  parameters:
    stream_id: enable
  states: {}
- name: virtual_source_6_0_1_0_0_1_2_0
  id: virtual_source
  parameters:
    stream_id: small_signal
  states: {}
- name: virtual_source_9_0
  id: virtual_source
  parameters:
    stream_id: TPy
  states: {}
- name: virtual_source_9_0_0
  id: virtual_source
  parameters:
    stream_id: TPz
  states: {}
- name: virtual_source_9_0_0_0
  id: virtual_source
  parameters:
    stream_id: attack
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:5555
    timeout: '1000'
    type: complex
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_const_source_x_1, '0', virtual_sink_2, '0']
- [analog_const_source_x_2, '0', blocks_multiply_xx_5, '1']
- [analog_const_source_x_2_0, '0', blocks_multiply_xx_6, '1']
- [analog_const_source_x_2_0_0, '0', blocks_multiply_xx_7, '1']
- [analog_const_source_x_2_1, '0', blocks_multiply_xx_5_0, '1']
- [analog_const_source_x_2_1, '0', blocks_multiply_xx_5_0_0, '1']
- [analog_fm_deemph_0_0, '0', blocks_multiply_xx_1, '0']
- [analog_fm_deemph_0_0, '0', blocks_sub_xx_1_1, '0']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_xx_1_0, '1']
- [analog_fm_deemph_0_0_0, '0', blocks_sub_xx_1_1, '1']
- [analog_fm_deemph_0_1, '0', blocks_multiply_xx_1_1_0, '0']
- [analog_fm_deemph_0_1, '0', blocks_sub_xx_1_0, '0']
- [analog_fm_deemph_0_1, '0', virtual_sink_7, '0']
- [analog_fm_deemph_0_1_0, '0', blocks_multiply_xx_1_1_0_1, '0']
- [analog_fm_deemph_0_1_0, '0', blocks_sub_xx_1_0, '1']
- [analog_fm_deemph_0_1_0, '0', virtual_sink_7_0, '0']
- [analog_fm_preemph_1, '0', virtual_sink_2_0_0_0_1_0_0_0, '0']
- [analog_rail_ff_0, '0', virtual_sink_0, '0']
- [analog_rail_ff_0_0, '0', virtual_sink_1, '0']
- [analog_rail_ff_0_0_0, '0', virtual_sink_4, '0']
- [analog_rail_ff_1, '0', envelope_probe, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_0, '0', rational_resampler_xxx_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_2, '0']
- [audio_source_0, '0', blocks_multiply_xx_5_0, '0']
- [audio_source_0, '1', blocks_multiply_xx_5_0_0, '0']
- [blocks_abs_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_abs_xx_1, '0', blocks_multiply_const_vxx_9_1, '0']
- [blocks_abs_xx_1_1, '0', blocks_multiply_const_vxx_9_1_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_1_0, '0']
- [blocks_add_const_vxx_0_0, '0', virtual_sink_2_0_0, '0']
- [blocks_add_const_vxx_0_0_1, '0', blocks_threshold_ff_1_0_2, '0']
- [blocks_add_const_vxx_0_0_1_0, '0', virtual_sink_2_0_0_0_1, '0']
- [blocks_add_const_vxx_0_0_1_0_0, '0', virtual_sink_2_0_0_0_1_0, '0']
- [blocks_add_const_vxx_0_0_1_0_1, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_const_vxx_0_1, '0', blocks_multiply_xx_4_2_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_add_xx_1, '0', low_pass_filter_0, '0']
- [blocks_add_xx_2, '0', analog_rail_ff_0_0, '0']
- [blocks_add_xx_2_0, '0', blocks_add_xx_5, '1']
- [blocks_add_xx_3, '0', blocks_delay_0_0, '0']
- [blocks_add_xx_3, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_add_xx_4, '0', blocks_multiply_xx_1_1_0_0, '0']
- [blocks_add_xx_4_0, '0', blocks_multiply_const_vxx_2_0_1, '0']
- [blocks_add_xx_5, '0', blocks_add_xx_5_0, '1']
- [blocks_add_xx_5_0, '0', low_pass_filter_1, '0']
- [blocks_add_xx_6, '0', blocks_delay_0_0_0, '0']
- [blocks_add_xx_6, '0', blocks_multiply_const_vxx_3_0, '0']
- [blocks_add_xx_7, '0', blocks_multiply_const_vxx_8_0, '0']
- [blocks_add_xx_8, '0', blocks_multiply_const_vxx_8, '0']
- [blocks_add_xx_9, '0', blocks_multiply_const_vxx_7_0, '0']
- [blocks_add_xx_9_0, '0', blocks_multiply_const_vxx_6_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_5_0, '0']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_5_0_0, '0']
- [blocks_delay_0, '0', blocks_null_sink_1_0, '1']
- [blocks_delay_0, '0', virtual_sink_5_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_10, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_7, '0']
- [blocks_delay_0_0, '0', low_pass_filter_3, '0']
- [blocks_delay_0_0_0, '0', blocks_multiply_const_vxx_10_0, '0']
- [blocks_delay_0_0_0, '0', blocks_multiply_const_vxx_6, '0']
- [blocks_delay_0_0_0, '0', low_pass_filter_2, '0']
- [blocks_float_to_uchar_0_0, '0', blocks_sample_and_hold_xx_0_0, '1']
- [blocks_float_to_uchar_0_0_0, '0', blocks_sample_and_hold_xx_0_0_0, '1']
- [blocks_float_to_uchar_0_0_0_0, '0', blocks_sample_and_hold_xx_0_0_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_xx_4_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_1_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_multiply_xx_4_2_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_sub_xx_1_0_0, '1']
- [blocks_multiply_const_vxx_1, '0', analog_rail_ff_1, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_10, '0', blocks_add_xx_9, '0']
- [blocks_multiply_const_vxx_10_0, '0', blocks_add_xx_9_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_2_0_1, '0', blocks_add_const_vxx_0_0_1, '0']
- [blocks_multiply_const_vxx_2_0_1_0, '0', blocks_add_const_vxx_0_0_1_0, '0']
- [blocks_multiply_const_vxx_2_0_1_0_0, '0', blocks_add_const_vxx_0_0_1_0_0, '0']
- [blocks_multiply_const_vxx_2_0_1_0_1, '0', blocks_add_const_vxx_0_0_1_0_1, '0']
- [blocks_multiply_const_vxx_2_1, '0', blocks_add_const_vxx_0_1, '0']
- [blocks_multiply_const_vxx_3, '0', high_pass_filter_0, '0']
- [blocks_multiply_const_vxx_3_0, '0', high_pass_filter_0_1, '0']
- [blocks_multiply_const_vxx_4, '0', analog_rail_ff_0_0_0, '0']
- [blocks_multiply_const_vxx_5, '0', blocks_add_xx_5_0, '0']
- [blocks_multiply_const_vxx_6, '0', blocks_add_xx_8, '0']
- [blocks_multiply_const_vxx_6_0, '0', blocks_add_xx_8, '1']
- [blocks_multiply_const_vxx_7, '0', blocks_add_xx_7, '0']
- [blocks_multiply_const_vxx_7_0, '0', blocks_add_xx_7, '1']
- [blocks_multiply_const_vxx_8, '0', blocks_multiply_const_vxx_9_0, '0']
- [blocks_multiply_const_vxx_8_0, '0', blocks_multiply_const_vxx_9, '0']
- [blocks_multiply_const_vxx_9, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_9, '0', blocks_abs_xx_1, '0']
- [blocks_multiply_const_vxx_9, '0', blocks_wavfile_sink_0, '0']
- [blocks_multiply_const_vxx_9_0, '0', audio_sink_0, '1']
- [blocks_multiply_const_vxx_9_0, '0', blocks_abs_xx_1_1, '0']
- [blocks_multiply_const_vxx_9_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_multiply_const_vxx_9_1, '0', qtgui_number_sink_1, '0']
- [blocks_multiply_const_vxx_9_1_0, '0', qtgui_number_sink_1, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1, '0', blocks_add_xx_2, '0']
- [blocks_multiply_xx_1_0, '0', blocks_add_xx_2, '1']
- [blocks_multiply_xx_1_1_0, '0', blocks_add_xx_2_0, '0']
- [blocks_multiply_xx_1_1_0_0, '0', blocks_add_xx_5, '0']
- [blocks_multiply_xx_1_1_0_0_0, '0', blocks_multiply_const_vxx_5, '0']
- [blocks_multiply_xx_1_1_0_1, '0', blocks_add_xx_2_0, '1']
- [blocks_multiply_xx_2, '0', rational_resampler_xxx_2, '0']
- [blocks_multiply_xx_2, '0', virtual_sink_3, '0']
- [blocks_multiply_xx_3, '0', blocks_multiply_const_vxx_2_0_1_0_0, '0']
- [blocks_multiply_xx_3, '0', virtual_sink_2_0_0_0_0_0_0, '0']
- [blocks_multiply_xx_4, '0', blocks_add_xx_4, '0']
- [blocks_multiply_xx_4_0, '0', blocks_add_xx_4, '1']
- [blocks_multiply_xx_4_1, '0', blocks_multiply_xx_4, '1']
- [blocks_multiply_xx_4_1_0, '0', blocks_multiply_xx_4_0, '1']
- [blocks_multiply_xx_4_2, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_4_2_0, '0', blocks_add_xx_1, '1']
- [blocks_multiply_xx_5, '0', blocks_add_xx_3, '1']
- [blocks_multiply_xx_5, '0', blocks_add_xx_6, '1']
- [blocks_multiply_xx_5_0, '0', blocks_add_xx_3, '0']
- [blocks_multiply_xx_5_0_0, '0', blocks_add_xx_6, '0']
- [blocks_multiply_xx_6, '0', blocks_add_xx_9, '1']
- [blocks_multiply_xx_7, '0', blocks_add_xx_9_0, '1']
- [blocks_sample_and_hold_xx_0_0, '0', virtual_sink_2_0_0_0_0, '0']
- [blocks_sample_and_hold_xx_0_0_0, '0', virtual_sink_2_0_0_0_0_0, '0']
- [blocks_sample_and_hold_xx_0_0_0_0, '0', blocks_multiply_xx_3, '0']
- [blocks_sub_xx_1_0, '0', blocks_threshold_ff_1_0, '0']
- [blocks_sub_xx_1_0, '0', blocks_threshold_ff_1_0_1, '0']
- [blocks_sub_xx_1_0_0, '0', blocks_threshold_ff_1_1_0, '0']
- [blocks_sub_xx_1_1, '0', blocks_threshold_ff_1_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_const_vxx_2_0_1_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '1']
- [blocks_threshold_ff_1_0, '0', blocks_multiply_xx_1_1_0, '1']
- [blocks_threshold_ff_1_0, '0', virtual_sink_2_0, '0']
- [blocks_threshold_ff_1_0_1, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_threshold_ff_1_0_2, '0', blocks_multiply_const_vxx_2_0_1_0, '0']
- [blocks_threshold_ff_1_0_2, '0', virtual_sink_2_0_0_0, '0']
- [blocks_threshold_ff_1_1, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_threshold_ff_1_1, '0', blocks_multiply_xx_1, '1']
- [blocks_threshold_ff_1_1_0, '0', blocks_multiply_const_vxx_2_1, '0']
- [blocks_threshold_ff_1_1_0, '0', blocks_multiply_xx_4_2, '1']
- [blocks_wavfile_source_0, '0', blocks_multiply_xx_5_0, '0']
- [blocks_wavfile_source_0, '1', blocks_multiply_xx_5_0_0, '0']
- [high_pass_filter_0, '0', blocks_abs_xx_0, '0']
- [high_pass_filter_0_1, '0', blocks_abs_xx_0_0, '0']
- [low_pass_filter_0, '0', analog_rail_ff_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_4, '0']
- [low_pass_filter_1, '0', blocks_null_sink_0, '0']
- [low_pass_filter_2, '0', blocks_multiply_xx_7, '0']
- [low_pass_filter_3, '0', blocks_multiply_xx_6, '0']
- [rational_resampler_xxx_1, '0', blocks_null_sink_1_0, '0']
- [rational_resampler_xxx_1, '0', virtual_sink_5, '0']
- [rational_resampler_xxx_2, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', blocks_threshold_ff_0, '0']
- [virtual_source_1, '0', analog_fm_deemph_0_1, '0']
- [virtual_source_1, '0', analog_fm_deemph_0_1_0, '0']
- [virtual_source_1_1, '0', analog_fm_preemph_1, '0']
- [virtual_source_2, '0', blocks_multiply_xx_5, '0']
- [virtual_source_2_1, '0', blocks_multiply_xx_1_1_0_1, '1']
- [virtual_source_4, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_4_0, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_6_0_0, '0', blocks_add_xx_4_0, '0']
- [virtual_source_6_0_0_0, '0', blocks_add_xx_4_0, '1']
- [virtual_source_6_0_0_1, '0', blocks_multiply_xx_1_1_0_0, '1']
- [virtual_source_6_0_1, '0', blocks_float_to_uchar_0_0, '0']
- [virtual_source_6_0_1_0, '0', blocks_float_to_uchar_0_0_0, '0']
- [virtual_source_6_0_1_0_0, '0', blocks_float_to_uchar_0_0_0_0, '0']
- [virtual_source_6_0_1_0_0_0, '0', blocks_multiply_xx_3, '1']
- [virtual_source_6_0_1_0_0_1, '0', blocks_multiply_xx_4, '0']
- [virtual_source_6_0_1_0_0_1_0, '0', blocks_multiply_xx_4_1, '0']
- [virtual_source_6_0_1_0_0_1_0_0, '0', blocks_multiply_xx_4_1_0, '0']
- [virtual_source_6_0_1_0_0_1_0_1, '0', blocks_multiply_xx_4_1, '1']
- [virtual_source_6_0_1_0_0_1_0_1_0, '0', blocks_multiply_xx_4_1_0, '1']
- [virtual_source_6_0_1_0_0_1_1, '0', blocks_multiply_xx_4_0, '0']
- [virtual_source_6_0_1_0_0_1_2, '0', blocks_multiply_xx_1_1_0_0_0, '1']
- [virtual_source_6_0_1_0_0_1_2_0, '0', blocks_multiply_xx_1_1_0_0_0, '0']
- [virtual_source_9_0, '0', blocks_sample_and_hold_xx_0_0, '0']
- [virtual_source_9_0_0, '0', blocks_sample_and_hold_xx_0_0_0, '0']
- [virtual_source_9_0_0_0, '0', blocks_sample_and_hold_xx_0_0_0_0, '0']
- [zeromq_req_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
