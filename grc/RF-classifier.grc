options:
  parameters:
    author: VideoMem
    copyright: GPL
    generate_options: qt_gui
    id: LD_RF_classifier
    output_language: python
    title: LaserDisc RF classifier
  states: {}

blocks:
- name: AC3_carrier
  id: variable
  parameters:
    value: AC3_carrier_ref + carrierR_fine + center_freq
  states: {}
- name: AC3_carrier_ref
  id: variable
  parameters:
    value: 182.857 * Fh
  states: {}
- name: EFM_LPF
  id: variable
  parameters:
    value: 1.75e6
  states: {}
- name: FM_HPF
  id: variable
  parameters:
    comment: Hz
    value: '120'
  states: {}
- name: Fh
  id: variable
  parameters:
    value: Fv*lines_per_frame/2
  states: {}
- name: Fhp
  id: variable
  parameters:
    value: Fvp*lines_per_frame_p/2
  states: {}
- name: Fv
  id: variable
  parameters:
    value: '60'
  states: {}
- name: Fvp
  id: variable
  parameters:
    value: '50'
  states: {}
- name: L_carrier
  id: variable
  parameters:
    value: L_carrier_ref + carrierL_fine + center_freq
  states: {}
- name: L_carrier_P
  id: variable
  parameters:
    value: L_carrier_ref_PAL + carrierL_fine + center_freq
  states: {}
- name: L_carrier_ref
  id: variable
  parameters:
    value: 146.25* Fh
  states: {}
- name: L_carrier_ref_PAL
  id: variable
  parameters:
    value: 61.849984 * Fhp
  states: {}
- name: R_carrier
  id: variable
  parameters:
    value: R_carrier_ref + carrierR_fine + center_freq
  states: {}
- name: R_carrier_P
  id: variable
  parameters:
    value: R_carrier_ref_PAL + carrierR_fine + center_freq
  states: {}
- name: R_carrier_ref
  id: variable
  parameters:
    value: 178.75 * Fh
  states: {}
- name: R_carrier_ref_PAL
  id: variable
  parameters:
    value: 165.12 * Fhp
  states: {}
- name: VCO_deviation
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: carrierL_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:1,0,1,1
    label: L Fine Tune
    orient: Qt.Horizontal
    start: '-5e3'
    step: '1'
    stop: 5e3
    value: '0'
  states: {}
- name: carrierR_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@1: 1,1,1,1'
    label: R Fine Tune
    orient: Qt.Horizontal
    start: '-5e3'
    step: '1'
    stop: 5e3
    value: '0'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1:0,0,1,2
    label: Center Fine
    min_len: '300'
    orient: Qt.Horizontal
    start: '-10e3'
    step: '0.1'
    stop: 10e3
    value: '0'
  states: {}
- name: half_VCO_deviation
  id: variable
  parameters:
    value: VCO_deviation/2
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: nearest.power(samp_rate/4,2)
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    value: '525'
  states: {}
- name: lines_per_frame_p
  id: variable
  parameters:
    value: '625'
  states: {}
- name: op_VCO_deviation
  id: variable
  parameters:
    value: VCO_deviation/3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: sharpness
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: Transition
    min_len: '300'
    orient: Qt.Horizontal
    rangeType: int
    start: int(op_VCO_deviation/4)
    step: '1'
    stop: int(VCO_deviation*2)
    value: int(VCO_deviation/2)
  states: {}
- name: analog_rail_ff_0
  id: analog_rail_ff
  parameters:
    hi: 1e3
    lo: '0'
  states: {}
- name: analog_rail_ff_0_0
  id: analog_rail_ff
  parameters:
    hi: 1e3
    lo: '0'
  states: {}
- name: analog_rail_ff_0_1
  id: analog_rail_ff
  parameters:
    hi: 1e3
    lo: '0'
  states: {}
- name: analog_rail_ff_0_1_0
  id: analog_rail_ff
  parameters:
    hi: 1e3
    lo: '0'
  states: {}
- name: analog_rail_ff_0_1_0_0
  id: analog_rail_ff
  parameters:
    hi: 1e3
    lo: '0'
  states: {}
- name: analog_rail_ff_0_1_1
  id: analog_rail_ff
  parameters:
    hi: '1'
    lo: '0'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '14'
    decim: '1'
    gain: 1/0xFF
    high_cutoff_freq: L_carrier + VCO_deviation /2
    low_cutoff_freq: L_carrier - VCO_deviation /2
    samp_rate: if_rate
    type: fir_filter_fff
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    beta: '14'
    decim: '1'
    gain: 1/0xFF
    high_cutoff_freq: R_carrier + VCO_deviation / 2
    low_cutoff_freq: 'R_carrier - VCO_deviation / 2 '
    samp_rate: if_rate
    type: fir_filter_fff
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    beta: '14'
    decim: '1'
    gain: 1/0xFF
    high_cutoff_freq: R_carrier_P + VCO_deviation / 2
    low_cutoff_freq: 'R_carrier_P - VCO_deviation / 2 '
    samp_rate: if_rate
    type: fir_filter_fff
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    beta: '14'
    decim: '1'
    gain: 1/0xFF
    high_cutoff_freq: L_carrier_P + VCO_deviation /2
    low_cutoff_freq: L_carrier_P - VCO_deviation /2
    samp_rate: if_rate
    type: fir_filter_fff
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    beta: '14'
    decim: '1'
    gain: 1/0xFF
    high_cutoff_freq: AC3_carrier + VCO_deviation /2
    low_cutoff_freq: AC3_carrier - VCO_deviation /2
    samp_rate: if_rate
    type: fir_filter_fff
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1e-3'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: round(if_rate /  FM_HPF)
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_1
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: round(if_rate /  FM_HPF)
    max_iter: '4000'
    scale: 1/round(if_rate / FM_HPF)
    type: float
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: round(if_rate /  FM_HPF)
    max_iter: '4000'
    scale: 1/round(if_rate /  FM_HPF)
    type: float
  states: {}
- name: blocks_moving_average_xx_1_0
  id: blocks_moving_average_xx
  parameters:
    length: round(if_rate /  FM_HPF)
    max_iter: '4000'
    scale: 1/round(if_rate /  FM_HPF)
    type: float
  states: {}
- name: blocks_moving_average_xx_1_1
  id: blocks_moving_average_xx
  parameters:
    length: round(if_rate /  FM_HPF)
    max_iter: '4000'
    scale: 1/round(if_rate /  FM_HPF)
    type: float
  states: {}
- name: blocks_moving_average_xx_1_1_0
  id: blocks_moving_average_xx
  parameters:
    length: round(if_rate /  FM_HPF)
    max_iter: '4000'
    scale: 1/round(if_rate /  FM_HPF)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.sqrt(2)/2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.sqrt(2)/2
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 100/3
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/5
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_6
  id: blocks_multiply_const_vxx
  parameters:
    const: '800'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0_0_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: float
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_3
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_3_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '14'
    cutoff_freq: EFM_LPF
    decim: '1'
    gain: 1/0xFF
    samp_rate: if_rate
    type: fir_filter_fff
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: nearest
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\nfrom math import log\n\ndef power(value, base):\n\tn = round(log(value,base))\n\treturn pow(base,n)\t\n\n\t\n"
  states: {}
- name: pipe_source_1
  id: pipe_source
  parameters:
    command: ld-ldf-reader "NTSC_side1_2020-01-18_07-26-55.ldf"
    out_type: short
    out_vlen: '1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    comment: NTSC METER
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0
    label1: NTSC
    min: '0'
    type: float
    unit1: (score)
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    comment: PAL METER
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0
    label1: PAL
    min: '0'
    type: float
    unit1: (score)
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    comment: AC3 METER
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0
    label1: AC3
    min: '0'
    type: float
    unit1: (score)
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    comment: EFM METER
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@0
    label1: EFM
    min: '0'
    type: float
    unit1: (score)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: tabs@3
    legend: 'False'
    size: '8192'
    srate: if_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(if_rate/samp_rate).limit_denominator(1000).denominator
    interp: Fraction(if_rate/samp_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Signal Score
    label1: Fine tuning
    label2: Output
    label3: Input
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AGC_if
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rf
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: NTSC_R
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: NTSC_L
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: PAL_L
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: PAL_R
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: IS_NTSC
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: PAL
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: EFM
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AGC_if
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: NTSC_R
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: PAL_L
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: IS_NTSC
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: PAL
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: EFM
  states: {}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: PAL
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: IS_NTSC
  states: {}

connections:
- [analog_rail_ff_0, '0', blocks_multiply_xx_0, '0']
- [analog_rail_ff_0_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [analog_rail_ff_0_1, '0', analog_rail_ff_0_1_1, '0']
- [analog_rail_ff_0_1, '0', qtgui_number_sink_0, '0']
- [analog_rail_ff_0_1_0, '0', virtual_sink_3, '0']
- [analog_rail_ff_0_1_0_0, '0', qtgui_number_sink_0_0, '0']
- [analog_rail_ff_0_1_1, '0', virtual_sink_2, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0, '0', virtual_sink_1_0, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0_0, '0', virtual_sink_1, '0']
- [band_pass_filter_0_0_0, '0', blocks_add_xx_0_0, '1']
- [band_pass_filter_0_0_0, '0', virtual_sink_1_0_0_0, '0']
- [band_pass_filter_0_1, '0', blocks_add_xx_0_0, '0']
- [band_pass_filter_0_1, '0', virtual_sink_1_0_0, '0']
- [band_pass_filter_0_2, '0', blocks_rms_xx_0_0_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_divide_xx_0, '1']
- [blocks_add_const_vxx_1, '0', blocks_divide_xx_1, '1']
- [blocks_add_xx_0, '0', blocks_rms_xx_0_0, '0']
- [blocks_add_xx_0_0, '0', blocks_rms_xx_0_0_0, '0']
- [blocks_delay_1, '0', blocks_sub_xx_0, '0']
- [blocks_divide_xx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_divide_xx_1, '0', analog_rail_ff_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_moving_average_xx_1, '0', analog_rail_ff_0, '0']
- [blocks_moving_average_xx_1_0, '0', blocks_sub_xx_3_0, '0']
- [blocks_moving_average_xx_1_0, '0', virtual_sink_4, '0']
- [blocks_moving_average_xx_1_1, '0', blocks_multiply_const_vxx_4, '0']
- [blocks_moving_average_xx_1_1_0, '0', analog_rail_ff_0_1_0, '0']
- [blocks_moving_average_xx_1_1_0, '0', blocks_sub_xx_3, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_2, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_sub_xx_2_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_sub_xx_2, '1']
- [blocks_multiply_const_vxx_0_0, '0', blocks_sub_xx_2_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_moving_average_xx_1, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_moving_average_xx_1_0, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_sub_xx_3, '1']
- [blocks_multiply_const_vxx_2_0, '0', blocks_sub_xx_3_0, '1']
- [blocks_multiply_const_vxx_3, '0', analog_rail_ff_0_1_0_0, '0']
- [blocks_multiply_const_vxx_4, '0', analog_rail_ff_0_1, '0']
- [blocks_multiply_const_vxx_5, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_6, '0', blocks_add_const_vxx_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_null_source_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_rms_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_rms_xx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_rms_xx_0_0_0_0, '0', blocks_sub_xx_1, '0']
- [blocks_rms_xx_0_0_0_0_0, '0', blocks_sub_xx_1, '1']
- [blocks_rms_xx_0_0_0_0_0_0, '0', blocks_sub_xx_1_0, '1']
- [blocks_rms_xx_0_0_0_0_1, '0', blocks_sub_xx_1_0, '0']
- [blocks_short_to_float_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_short_to_float_0_0, '0', virtual_sink_0_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_const_vxx_5, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_sub_xx_1_0, '0', blocks_divide_xx_0, '0']
- [blocks_sub_xx_2, '0', blocks_moving_average_xx_1_1, '0']
- [blocks_sub_xx_2_0, '0', blocks_moving_average_xx_1_1_0, '0']
- [blocks_sub_xx_3, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_sub_xx_3_0, '0', blocks_divide_xx_1, '0']
- [low_pass_filter_0, '0', blocks_rms_xx_0_0_0_0_1, '0']
- [pipe_source_1, '0', blocks_short_to_float_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_1, '0']
- [rational_resampler_xxx_0, '0', blocks_moving_average_xx_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_1, '0']
- [virtual_source_0, '0', band_pass_filter_0_2, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']
- [virtual_source_1, '0', blocks_rms_xx_0_0_0_0_0, '0']
- [virtual_source_1_0, '0', blocks_rms_xx_0_0_0_0_0_0, '0']
- [virtual_source_2, '0', blocks_multiply_xx_0, '1']
- [virtual_source_3, '0', blocks_add_const_vxx_0, '0']
- [virtual_source_4, '0', blocks_multiply_const_vxx_2, '0']
- [virtual_source_4_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [virtual_source_5, '0', blocks_multiply_const_vxx_6, '0']

metadata:
  file_format: 1
