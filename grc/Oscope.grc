options:
  parameters:
    author: VideoMem
    generate_options: qt_gui
    id: Oscope
    output_language: python
    title: oscope
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: pipe_source_0
  id: pipe_source
  parameters:
    command: python3 ~/Develop/Superheterodyne-decoding-tools/RFprobe/tests/block_gen.py 256
    out_type: short
    out_vlen: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    legend: 'False'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [pipe_source_0, '0', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
