options:
  parameters:
    author: VideoMem
    copyright: GPL
    generate_options: qt_gui
    id: Superheterodyne_HIFI_decoder
    output_language: python
    title: Superheterodyne HIFI decoder
  states: {}

blocks:
- name: Fh
  id: variable
  parameters:
    value: Fv*lines_per_frame/2
  states: {}
- name: Fv
  id: variable
  parameters:
    comment: |-
      50 (PAL)
      60 (NTSC)
    value: '60'
  states: {}
- name: L_carrier
  id: variable
  parameters:
    value: L_carrier_ref + carrierL_fine + center_freq
  states: {}
- name: L_carrier_ref
  id: variable
  parameters:
    value: 146.25* Fh
  states: {}
- name: RMS_average
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: Gate Average
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: round(pop_len*10)
    value: round(pop_len*10/2)
  states: {}
- name: RMS_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: Gate Peak
    orient: Qt.Horizontal
    start: '0'
    step: '0.0001'
    stop: '0.1'
    value: '0.05'
  states: {}
- name: R_carrier
  id: variable
  parameters:
    value: R_carrier_ref + carrierR_fine + center_freq
  states: {}
- name: R_carrier_ref
  id: variable
  parameters:
    value: 178.75 * Fh
  states: {}
- name: VCO_deviation
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 192e3
  states: {}
- name: balance
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0: 4,0,1,2'
    label: Balance
    orient: Qt.Horizontal
    start: '0.25'
    step: '0.01'
    stop: '0.75'
    value: '0.5'
  states: {}
- name: carrierL_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:1,0,1,1
    label: L Fine Tune
    orient: Qt.Horizontal
    start: '-5e3'
    step: '1'
    stop: 5e3
    value: '0'
  states: {}
- name: carrierR_fine
  id: variable_qtgui_range
  parameters:
    gui_hint: 'tabs@0: 1,1,1,1'
    label: R Fine Tune
    orient: Qt.Horizontal
    start: '-5e3'
    step: '1'
    stop: 5e3
    value: '-112'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: Center Fine
    min_len: '300'
    orient: Qt.Horizontal
    start: '-10e3'
    step: '0.1'
    stop: 10e3
    value: '-10000'
  states: {}
- name: fh_comb_delay
  id: variable
  parameters:
    value: round(audio_rate/(2*Fh))
  states: {}
- name: filter_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@3
    label: EQ Delay
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 26*2
    value: '42'
  states: {}
- name: half_VCO_deviation
  id: variable
  parameters:
    value: VCO_deviation/2
  states: {}
- name: if_rate
  id: variable
  parameters:
    value: nearest.power(samp_rate/4,2)
  states: {}
- name: left_balance
  id: variable
  parameters:
    value: 1 - balance
  states: {}
- name: left_squelch
  id: variable_function_probe
  parameters:
    block_id: LS_signal
    function_name: level
    poll_rate: audio_rate
    value: '0'
  states: {}
- name: lines_per_frame
  id: variable
  parameters:
    comment: |-
      625 (PAL)
      525 (NTSC)
      624 (PAL 624)
    value: '525'
  states: {}
- name: op_VCO_deviation
  id: variable
  parameters:
    value: VCO_deviation/3
  states: {}
- name: pop_len
  id: variable
  parameters:
    value: audio_rate*(pop_time/2)
  states: {}
- name: pop_time
  id: variable
  parameters:
    value: '2e-3'
  states: {}
- name: right_balance
  id: variable
  parameters:
    value: 1-left_balance
  states: {}
- name: right_squelch
  id: variable_function_probe
  parameters:
    block_id: RS_signal
    function_name: level
    poll_rate: audio_rate
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: sharpness
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@1
    label: Transition
    min_len: '300'
    orient: Qt.Horizontal
    rangeType: int
    start: int(op_VCO_deviation/4)
    step: '1'
    stop: int(op_VCO_deviation*2)
    value: round(op_VCO_deviation/2)
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,1,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0.7'
  states: {}
- name: LS_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: RS_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: 1/Fh
    decay_rate: 1/Fh
    gain: '1'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: 1/Fh
    decay_rate: 1/Fh
    gain: '1'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_agc2_xx_0_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: 1/Fh
    decay_rate: 1/Fh
    gain: '1'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: if_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: if_rate
    tau: '75e-6'
  states: {}
- name: analog_fm_deemph_2
  id: analog_fm_deemph
  parameters:
    samp_rate: if_rate
    tau: '25e-6'
  states: {}
- name: analog_fm_deemph_2_0
  id: analog_fm_deemph
  parameters:
    samp_rate: if_rate
    tau: '25e-6'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: if_rate/(2*math.pi*VCO_deviation/8.0)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: if_rate/(2*math.pi*VCO_deviation/8.0)
  states: {}
- name: analog_rail_ff_1_1
  id: analog_rail_ff
  parameters:
    hi: '0.999'
    lo: '-0.999'
  states: {}
- name: analog_rail_ff_1_1_0
  id: analog_rail_ff
  parameters:
    hi: '0.999'
    lo: '-0.999'
  states: {}
- name: analog_rail_ff_1_1_1
  id: analog_rail_ff
  parameters:
    hi: '0.999'
    lo: '-0.999'
  states: {}
- name: analog_rail_ff_1_1_1_0
  id: analog_rail_ff
  parameters:
    hi: '0.999'
    lo: '-0.999'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: L_carrier
    offset: '0'
    phase: '0'
    samp_rate: if_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: R_carrier
    offset: '0'
    phase: '0'
    samp_rate: if_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: '820'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: round(audio_rate)
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: L_carrier + VCO_deviation /2
    low_cutoff_freq: L_carrier - VCO_deviation /2
    samp_rate: if_rate
    type: fir_filter_ccf
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: R_carrier + VCO_deviation / 2
    low_cutoff_freq: 'R_carrier - VCO_deviation / 2 '
    samp_rate: if_rate
    type: fir_filter_ccf
    width: sharpness
    win: firdes.WIN_KAISER
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_2_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_add_xx_3_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_3_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: fh_comb_delay
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: fh_comb_delay
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: filter_delay
    type: float
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: filter_delay
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: VTR/LD/pioneer.r16
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    const: left_squelch
    type: float
  states: {}
- name: blocks_multiply_const_vxx_6
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 - right_squelch
    type: float
  states: {}
- name: blocks_multiply_const_vxx_7
  id: blocks_multiply_const_vxx
  parameters:
    const: 1 - left_squelch
    type: float
  states: {}
- name: blocks_multiply_const_vxx_8
  id: blocks_multiply_const_vxx
  parameters:
    const: right_squelch
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: 1/1024
    type: float
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: 1/1024
    type: float
  states: {}
- name: blocks_rms_xx_0_0_0
  id: blocks_rms_xx
  parameters:
    alpha: 1/RMS_average
    type: float
  states: {}
- name: blocks_rms_xx_0_2
  id: blocks_rms_xx
  parameters:
    alpha: 1/RMS_average
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: RMS_threshold*volume
    init: '0'
    low: RMS_threshold*volume
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: RMS_threshold*volume
    init: '0'
    low: RMS_threshold*volume
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: demodulated_hifi.wav
    nchan: '2'
    samp_rate: round(audio_rate)
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: round(samp_rate/100)
    long_form: 'True'
    type: ff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: L_carrier
    decim: '1'
    samp_rate: if_rate
    taps: '1'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: R_carrier
    decim: '1'
    samp_rate: if_rate
    taps: '1'
    type: ccc
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_KAISER
  states: {}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_KAISER
  states: {}
- name: high_pass_filter_1
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '30'
    decim: '1'
    gain: 2*left_balance
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '15'
    win: firdes.WIN_KAISER
  states: {}
- name: high_pass_filter_1_0
  id: high_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '30'
    decim: '1'
    gain: 2*right_balance
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '15'
    win: firdes.WIN_KAISER
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from fractions import Fraction
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: 70e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: 70e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '20000'
    decim: '1'
    gain: 0.35*volume
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '4000'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: '20000'
    decim: '1'
    gain: 0.35*volume
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '4000'
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 1e3
    decim: '1'
    gain: '-1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: 3e3
    win: firdes.WIN_KAISER
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    beta: '6.76'
    cutoff_freq: 1e3
    decim: '1'
    gain: '-1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: 3e3
    win: firdes.WIN_KAISER
  states: {}
- name: nearest
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\n\nfrom math import log\n\ndef power(value, base):\n\tn = round(log(value,base))\n\treturn pow(base,n)\t\n\n\t\n"
  states: {}
- name: pipe_source_1
  id: pipe_source
  parameters:
    command: ld-ldf-reader /home/sebastian/Downloads/VTR/LD/GulliversTravels_Side1.ldf.part.oga
    out_type: short
    out_vlen: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: if_rate
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: tabs@0
    legend: 'False'
    nconnections: '3'
    type: float
    wintype: firdes.WIN_KAISER
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 'tabs@0: 3,0,1,2'
    label1: L
    label2: R
    max: '5'
    min: '0'
    name: '"Level-Meter"'
    nconnections: '2'
    type: float
    unit1: Vpp x10
    unit2: Vpp x10
    update_time: '0.05'
  states: {}
- name: qtgui_number_sink_0_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: tabs@1
    label1: L
    min: '0'
    name: '"Level-Meter"'
    type: float
    unit1: V
    update_time: '0.05'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tabs@3
    legend: 'False'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@2
    name: '"Main"'
    nconnections: '2'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(if_rate/samp_rate).limit_denominator(1000).denominator
    interp: Fraction(if_rate/samp_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(audio_rate/if_rate).limit_denominator(1000).denominator
    interp: Fraction(audio_rate/if_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: Fraction(audio_rate/if_rate).limit_denominator(1000).denominator
    interp: Fraction(audio_rate/if_rate).limit_denominator(1000).numerator
    taps: ''
    type: fff
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Main
    label1: Noise gate
    label2: Output
    label3: Filter delay
    num_tabs: '4'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: AGC_if
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: rf
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: L
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: R
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: preR
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: preL
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: CH2
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: CH1
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: Notches_L_out
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: Notches_R_out
  states: {}
- name: virtual_sink_8
  id: virtual_sink
  parameters:
    stream_id: Notches_L_in
  states: {}
- name: virtual_sink_9
  id: virtual_sink
  parameters:
    stream_id: Notches_R_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: AGC_if
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_1_1_1
  id: virtual_source
  parameters:
    stream_id: preL
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_2_1_1
  id: virtual_source
  parameters:
    stream_id: preR
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: CH2
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: CH1
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: Notches_L_out
  states: {}
- name: virtual_source_8_0
  id: virtual_source
  parameters:
    stream_id: Notches_L_in
  states: {}
- name: virtual_source_9
  id: virtual_source
  parameters:
    stream_id: Notches_R_out
  states: {}
- name: virtual_source_9_0
  id: virtual_source
  parameters:
    stream_id: Notches_R_in
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://0.0.0.0:5555
    timeout: '1000'
    type: complex
  states: {}

connections:
- [analog_agc2_xx_0, '0', virtual_sink_0, '0']
- [analog_agc2_xx_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [analog_agc2_xx_0_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_fm_deemph_0, '0', analog_fm_deemph_2, '0']
- [analog_fm_deemph_0_0, '0', analog_fm_deemph_2_0, '0']
- [analog_fm_deemph_2, '0', rational_resampler_xxx_1, '0']
- [analog_fm_deemph_2_0, '0', rational_resampler_xxx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', analog_fm_deemph_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', analog_fm_deemph_0_0, '0']
- [analog_rail_ff_1_1, '0', audio_sink_0, '0']
- [analog_rail_ff_1_1, '0', blocks_float_to_complex_1, '0']
- [analog_rail_ff_1_1, '0', blocks_wavfile_sink_0, '0']
- [analog_rail_ff_1_1, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_rail_ff_1_1_0, '0', audio_sink_0, '1']
- [analog_rail_ff_1_1_0, '0', blocks_float_to_complex_1, '1']
- [analog_rail_ff_1_1_0, '0', blocks_wavfile_sink_0, '1']
- [analog_rail_ff_1_1_0, '0', qtgui_waterfall_sink_x_0, '1']
- [analog_rail_ff_1_1_1, '0', virtual_sink_8, '0']
- [analog_rail_ff_1_1_1_0, '0', virtual_sink_9, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_sig_source_x_0_0, '0', qtgui_freq_sink_x_0, '2']
- [band_pass_filter_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [band_pass_filter_0, '0', virtual_sink_3, '0']
- [band_pass_filter_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [band_pass_filter_0_0, '0', virtual_sink_2, '0']
- [blocks_add_xx_0, '0', qtgui_number_sink_0_1_1, '0']
- [blocks_add_xx_1, '0', blocks_complex_to_real_0, '0']
- [blocks_add_xx_2, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_add_xx_2_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [blocks_add_xx_3_0_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_3_1, '0', low_pass_filter_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_7, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_6, '0']
- [blocks_delay_1, '0', blocks_add_xx_3_1, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_1_0, '0', blocks_add_xx_3_0_0, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_complex_0, '0', analog_agc2_xx_0, '0']
- [blocks_float_to_complex_1, '0', zeromq_rep_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_number_sink_0_1, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_number_sink_0_1, '1']
- [blocks_multiply_const_vxx_3, '0', virtual_sink_6, '0']
- [blocks_multiply_const_vxx_3_0, '0', virtual_sink_7, '0']
- [blocks_multiply_const_vxx_5, '0', blocks_add_xx_2, '1']
- [blocks_multiply_const_vxx_6, '0', blocks_add_xx_2_0, '2']
- [blocks_multiply_const_vxx_7, '0', blocks_add_xx_2, '2']
- [blocks_multiply_const_vxx_8, '0', blocks_add_xx_2_0, '1']
- [blocks_null_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_rms_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_rms_xx_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_rms_xx_0_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_rms_xx_0_2, '0', blocks_threshold_ff_0, '0']
- [blocks_short_to_float_0, '0', dc_blocker_xx_0, '0']
- [blocks_short_to_float_0, '0', virtual_sink_0_0, '0']
- [blocks_threshold_ff_0, '0', LS_signal, '0']
- [blocks_threshold_ff_0, '0', blocks_add_xx_0, '0']
- [blocks_threshold_ff_0_0, '0', RS_signal, '0']
- [blocks_threshold_ff_0_0, '0', blocks_add_xx_0, '1']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_agc2_xx_0_0_0, '0']
- [high_pass_filter_0, '0', low_pass_filter_1, '0']
- [high_pass_filter_0_0, '0', low_pass_filter_1_0, '0']
- [high_pass_filter_1, '0', low_pass_filter_0_1, '0']
- [high_pass_filter_1_0, '0', low_pass_filter_0_0_0, '0']
- [low_pass_filter_0, '0', high_pass_filter_1_0, '0']
- [low_pass_filter_0_0, '0', high_pass_filter_1, '0']
- [low_pass_filter_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_0_0_0, '0', virtual_sink_1_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_1, '0', virtual_sink_1_1, '0']
- [low_pass_filter_1, '0', blocks_add_xx_3_1, '1']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0, '1']
- [low_pass_filter_1_0, '0', blocks_add_xx_3_0_0, '1']
- [pipe_source_1, '0', blocks_short_to_float_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_1, '0', blocks_delay_1, '0']
- [rational_resampler_xxx_1, '0', blocks_null_sink_0, '0']
- [rational_resampler_xxx_1, '0', high_pass_filter_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_delay_1_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_null_sink_0, '1']
- [rational_resampler_xxx_1_0, '0', high_pass_filter_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', band_pass_filter_0_0, '0']
- [virtual_source_1, '0', analog_rail_ff_1_1_1, '0']
- [virtual_source_1_1, '0', blocks_rms_xx_0, '0']
- [virtual_source_1_1_1, '0', blocks_rms_xx_0_2, '0']
- [virtual_source_2, '0', analog_rail_ff_1_1_1_0, '0']
- [virtual_source_2_1, '0', blocks_rms_xx_0_0, '0']
- [virtual_source_2_1_1, '0', blocks_rms_xx_0_0_0, '0']
- [virtual_source_3, '0', blocks_add_xx_1, '0']
- [virtual_source_4, '0', blocks_add_xx_1, '1']
- [virtual_source_8, '0', analog_rail_ff_1_1, '0']
- [virtual_source_8_0, '0', blocks_add_xx_2, '0']
- [virtual_source_8_0, '0', blocks_delay_0, '0']
- [virtual_source_8_0, '0', blocks_multiply_const_vxx_5, '0']
- [virtual_source_9, '0', analog_rail_ff_1_1_0, '0']
- [virtual_source_9_0, '0', blocks_add_xx_2_0, '0']
- [virtual_source_9_0, '0', blocks_delay_0_0, '0']
- [virtual_source_9_0, '0', blocks_multiply_const_vxx_8, '0']

metadata:
  file_format: 1
